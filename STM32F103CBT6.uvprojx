# Keil uVision project STM32F103CBT6.uvprojx, settings and files
target STM32F103CBT6 (6220000::V6.22::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103CBT6
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Util;.\System;.\Hardware;.\Hardware\OLED;.\Hardware\LCD;.\U8g2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Source/: main.c main.h define.c task.c interrupt.c
  group Util
    ./Util/: Delay.c Delay.h Encoder.c Encoder.h PID.c PID.h PWM.c PWM.h PWMI.c PWMI.h Serial.c Serial.h Sampler.c Sampler.h Timer.c Timer.h
  group Systrm
    ./System/: ADC.c ADC.h Capture.c Capture.h Compare.c Compare.h DMA.c DMA.h GPIO.c GPIO.h Interrupt.c Interrupt.h RTC.c RTC.h TIM.c TIM.h USART.c USART.h
  group Hardware
    ./Hardware/: Key.c Key.h LED.c LED.h Motor.c Motor.h Servo.c Servo.h W25Q64.c W25Q64.h MQSensor.c MQSensor.h
    ./Hardware/OLED/: OLED.c OLED.h OLED_Font.c OLED_Font.h OLED_I2C.c OLED_I2C.h OLED_SPI.c OLED_SPI.h Menu.c Menu.h
    ./Hardware/LCD/: LCD.c LCD.h LCD_Font.c LCD_Font.h LCD_SPI.c LCD_SPI.h
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.1.0, RTOS:Config 11.1.0, RTOS:Core 11.1.0, RTOS:Event Groups 11.1.0, RTOS:Heap 11.1.0, RTOS:Timers 11.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:CAN 3.6.0, Device:StdPeriph Drivers:CEC 3.6.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:DAC 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:SDIO 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0, Device:StdPeriph Drivers:WWDG 3.6.0
